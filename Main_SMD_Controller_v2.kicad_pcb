# Repository EosinY/ElectronicLoad-AnalogController

## KiCad design Main_SMD_Controller_v2.kicad_pcb

Parts:
C101, C102, C103, C104, C111, C112, C115, C116, C117, C118, C119, C121, C122, C124, C125: 0.1u; C_0603_1608Metric
C105, C106, C107, C108: 47u; CP_Elec_6.3x5.9
C109, C110: 1u; C_0603_1608Metric
C113, C114: 4.7u; C_1210_3225Metric
C120, C123: NC; C_0603_1608Metric; not fitted
D101: GS1010FL; D_SOD-123F
FB101, FB102: BLM21PG331SN; L_Axial_L5.3mm_D2.2mm_P2.54mm_Vertical_Vishay_IM-1
FB103, FB104: BLM21PG331SN; L_0805_2012Metric
H101, H102, H103, H104: MountingHole; MountingHole_3.2mm_M3
J101, J102: ETB43034G000Z; EurostylePluggable_1x03_P5.08mm
J105: B2P3-VH-3.3; JST_VH_B2P3-VH_1x02_P7.92mm_Vertical
J106: PH-1X3SG; PinHeader_1x03_P2.54mm_Vertical
J107, J109, J111, J112: PCB-20; ScrewTerminal_01x01_PCB-20
J108: B2B-XH-A; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J110: PH-1X2SG; PinHeader_1x02_P2.54mm_Vertical
P101: Eoshi-chan_Silk; Eoshi-chan-v2_7x7
R101, R109: 1k(0.1); R_0805_2012Metric
R102: 150(0.5); R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R103: 470(0.5); R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R104: 1.5k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R105: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R106, R108, R114: 10k(0.1); R_0805_2012Metric
R107: 2.2k(0.5); R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R110: 39k(0.5); R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R111: 1k(0.5); R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R112, R115: 0; R_0805_2012Metric
R113: 100k(0.1); R_0805_2012Metric
R116: 200; R_0603_1608Metric
R117: BR3FB10L0 (10m); R_Bare_Metal_Element_L16.3mm_W4.8mm_P15.30mm
RLY101: 943-1C-5DS; HSINDA-943_12A-1C_5p; MPN G5LE-14 DC5; Digi-Key_PN Z1011-ND
RV101: 10; Potentiometer_Bourns_3296W_Vertical
RV102: 50; Potentiometer_Bourns_3296W_Vertical
RV103: 200; Potentiometer_Bourns_3296W_Vertical
RV104: 500; Potentiometer_Bourns_3296W_Vertical
TP101, TP102, TP103, TP104: RCTCTE; RCTCE
U101: XC6201P332MR-G; SOT-23-5
U102: XC6902N331MR-G; SOT-23-3
U103: TC4066BP; DIP-14_W7.62mm
U104: ADA4510-2ARZ; SOIC-8_3.9x4.9mm_P1.27mm
U105: MCP1501-20E/CHY; SOT-23-6
U106: AD623ANZ; DIP-8_W7.62mm
U107: NJU7098A; SOT-23-6

Connections:
+3V3: C111.1, C113.1, C115.1, C117.1, C118.1, C121.1, C124.1, U101.5 (V_{OUT}), U103.14 (V_{DD}), U104.8 (VDD), U105.4 (~SHDN), U105.6 (VDD), U106.7 (VCC), U107.6 (VDD); also elsewhere on the board
+5V: C105.1, C109.1, D101.1 (K), FB103.2, RLY101.2 (COIL), U101.1 (V_{IN}); also elsewhere on the board
-3V3: C112.2, C114.1, C116.1, C119.1, C122.1, C125.1, U102.1 (-V_{OUT}), U103.7 (V_{SS}), U104.4 (VSS), U106.4 (VEE), U107.2 (VEE); also elsewhere on the board
-5V: C106.2, C110.1, FB104.2, U102.3 (-V_{IN})
/ADC_Vref: R113.1, TP102.1 (1_1), U105.1 (OUT); also elsewhere on the board
/GAIN0: U103.13; also elsewhere on the board
/GAIN1: U103.5; also elsewhere on the board
/GAIN2: U103.12; also elsewhere on the board
/GAIN3: U103.6; also elsewhere on the board
/GAIN_SEL1: U103.2, U103.4, U103.8, U103.10, U106.1
/GAIN_SEL2: RV101.1, RV101.2, RV102.1, RV102.2, RV103.1, RV103.2, RV104.1, RV104.2, U106.8
/Imeas: TP103.1 (1_1), U106.6; also elsewhere on the board
/Load+: J111.1 (Pin_1_1), RLY101.3 (NO)
/MOS_D: J106.3, J107.1 (Pin_1_1), RLY101.1 (COM)
/MOS_G: J108.1; also elsewhere on the board
/MOS_S: J109.1 (Pin_1_1), R117.1, U106.3
/OFS: J110.1, R109.2, R116.2, TP104.1 (1_1), U106.5 (Ref), U107.1; also elsewhere on the board
/RLY_LOUT: D101.2 (A), RLY101.5 (COIL); also elsewhere on the board
/Vin: C120.1, R110.2, R111.2, U104.5
/Vmeas: R101.1, TP101.1 (1_1), U104.7; also elsewhere on the board
GND: C101.2, C102.1, C103.2, C104.1, C105.2, C106.1, C107.2, C108.1, C109.2, C110.2, C111.2, C112.1, C113.2, C114.2, C115.2, C116.2, C117.2, C118.2, C119.2, C121.2, C122.2, C123.2, C124.2, C125.2, J101.2, J102.2, J108.2, J110.2, R112.1, R114.1, R115.2, U101.2 (GND), U102.2 (GND), U105.2 (GND), U105.3 (GND), U105.5 (GND); also elsewhere on the board
GNDA: C120.2, J105.2, J112.1 (Pin_1_1), R111.1, R112.2, R115.1, R117.2, RLY101.4 (NC), U104.3, U106.2
unnamed: C123.1, R113.2, R114.2, U107.3
unnamed: C101.1, FB101.1, J101.1
unnamed: C102.2, FB102.1, J101.3
unnamed: C103.1, FB103.1, J102.1
unnamed: C104.2, FB104.1, J102.3
unnamed: J105.1, J106.1
unnamed: J106.2, R110.1
unnamed: R101.2, R106.1, R107.1, U104.6
unnamed: R102.1, U103.1
unnamed: R102.2, RV101.3
unnamed: R103.1, U103.3
unnamed: R103.2, RV102.3
unnamed: R104.1, U103.9
unnamed: R104.2, RV103.3
unnamed: R105.1, U103.11
unnamed: R105.2, RV104.3
unnamed: R106.2, R108.1, U104.1
unnamed: R107.2, R108.2, R109.1, U104.2
unnamed: R116.1, U107.4
VCC: C107.1, FB101.2; also elsewhere on the board
VEE: C108.2, FB102.2; also elsewhere on the board

Notes on the sheet:
MOSFET: S BJT,IGBT: E
320mA
V_{in2}
V_{ref}
Vo := G(V_{in1}-V_{in2})+V_{ref} G := 1 + R4/R3 + 2*R2/Rg = 2.009
0.1862V
Memo: GAIN2,3を入れ替える GreenPAKのFWを変更
V_{IN}=1/40*V_{SENS}
入力-
3.2A
R2/R1 == R4/R3
f_{c}=160Hz
V_{SENS}: 0~40V
入力+
V_{MEAS}: 0~2V
MOSFET,IGBT: G BJT: B
2.048V
MOSFET: D BJT,IGBT: C
10A
V_{in1}

Parts:
C201, C202, C210, C211: 0.1u; C_0603_1608Metric
C203: 0.01u(FL); C_0805_2012Metric; not fitted
C204, C209: NC; C_0603_1608Metric; not fitted
C205, C206: NC; C_0805_2012Metric; not fitted
C207, C208, C212: 1000p(FL); C_0805_2012Metric
C213: 10p; C_0603_1608Metric; not fitted
C214: 0.047u(FL); C_Rect_L7.2mm_W5.0mm_P5.00mm; not fitted
HS201: Heatsink_Pad_2Pin; Heatsink_61x30x30
Q201: 2SC1815; TO-92L_Inline
Q202, Q204: 2SD1415A; TO-220-3_Vertical
Q203, Q205: TTB1020B; TO-220-3_Vertical
R201, R203, R207, R208: 0; R_0603_1608Metric
R202, R218: 1k; R_0603_1608Metric
R204, R205: 1M; R_0603_1608Metric
R206: NC; R_0603_1608Metric; not fitted
R209: 10k; R_0603_1608Metric
R210: 100k; R_0603_1608Metric
R211: 3.3k; R_0805_2012Metric
R212, R214: 510; R_2512_6332Metric
R213: 1k; R_0805_2012Metric
R215: 33k; R_0805_2012Metric
R216, R217, R221, R222: 470; R_1206_3216Metric
R219, R220, R223, R224: 1; R_Box_L14.0mm_W5.0mm_P9.00mm
R225: 4.7; R_2512_6332Metric; not fitted
RV201: 2k; TSR-065-xxx-R
TP201, TP202: RCTCTE; RCTCE
U201: ADA4522-1ARZ; SOIC-8_3.9x4.9mm_P1.27mm
U202: KIA75S358F; SOT-23-5

Connections:
+3V3: C201.1, U201.7 (VCC); also elsewhere on the board
-3V3: C202.1, U201.4 (VEE); also elsewhere on the board
/Imeas: C203.1, R202.1; also elsewhere on the board
/MOS_G: C213.2, R218.2, R219.2, R220.1, R223.2, R224.1, R225.1; also elsewhere on the board
/rt: R201.1; also elsewhere on the board
GND: C201.2, C202.2, C204.2, C209.2, C210.2, C211.2, C214.2, R209.2, R210.2; also elsewhere on the board
unnamed: C203.2, C205.1, C206.1, R202.2, R204.1, R205.1, R206.1, U201.2
unnamed: C204.1, R203.2, U201.3
unnamed: C205.2, C206.2, C207.2, C208.2, R206.2, R207.1, U201.6
unnamed: C207.1, C208.1, R204.2, R205.2
unnamed: C209.1, R208.2, R209.1, U202.1
unnamed: C212.1, C213.1, R210.1, R218.1, U202.3
unnamed: C214.1, R225.2
unnamed: Q201.3 (B), RV201.2
unnamed: C212.2, Q201.2 (C), R211.1, R212.2, R215.1, R216.1, R221.1, U202.4
unnamed: Q201.1 (E), R213.2, R214.1, R217.1, R222.1
unnamed: Q202.1 (B), R216.2
unnamed: Q202.3 (E), R219.1
unnamed: Q203.1 (B), R217.2
unnamed: Q203.2 (E), R220.2
unnamed: Q204.1 (B), R221.2
unnamed: Q204.3 (E), R223.1
unnamed: Q205.1 (B), R222.2
unnamed: Q205.2 (E), R224.2
unnamed: R201.2, R203.1, TP201.1 (1_1)
unnamed: R207.2, R208.1, TP202.1 (1_1)
unnamed: R211.2, R215.2, RV201.3
unnamed: R213.1, RV201.1
VCC: C210.1, Q202.2 (C), Q204.2 (C), R212.1, U202.5 (VCC); also elsewhere on the board
VEE: C211.1, Q203.3 (C), Q205.3 (C), R214.2, U202.2 (VEE); also elsewhere on the board

Parts:
C301, C302, C303, C304, C305, C306, C309: 0.1u; C_0603_1608Metric
C307, C308, C310, C311, C312: 1000p; C_0603_1608Metric
D301: OSBL1608C1A; LED_0603_1608Metric
D302: OSHR1608C1A; LED_0603_1608Metric
D303: OSYG1608; LED_0603_1608Metric
J301: BH-14SG; IDC-Header_2x07_P2.54mm_Vertical
J302: PH-2x3SG; PinHeader_2x03_P2.54mm_Vertical
J303: PH-1X3SG; PinHeader_1x03_P2.54mm_Vertical
J304: B2B-XH-A; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
Q301, Q302, Q304, Q305: 2N7002K; SOT-23
Q303: BSS84; SOT-23
R301, R302, R304, R306, R307, R308, R309, R310, R311, R312, R313, R314, R315, R317: 10k; R_0603_1608Metric
R303, R305, R316: 1k; R_0603_1608Metric
R318, R319: 0; R_0805_2012Metric
R320, R321, R322, R323, R324: 200; R_0603_1608Metric
TP301: RCTCTE; RCTCE
U301: 74LCX541FT; TSSOP-20_4.4x6.5mm_P0.65mm
U302: SLG46826G; TSSOP-20_4.4x6.5mm_P0.65mm
U303: PCA9515AD; SOIC-8_3.9x4.9mm_P1.27mm
U304: MCP4726A0T-ECH; SOT-23-6
U305: MCP3424T-ESL; SOIC-14_3.9x8.7mm_P1.27mm
U306: MCP9701A-E_TO; TO-92_Inline; MPN MCP9701A-E/TO; Digi-Key_PN MCP9701A-E/TO-ND

Connections:
+3V3: C301.1, C302.1, C303.1, C304.1, C305.1, C306.1, C309.1, Q303.2 (S), R301.2, R309.2, R311.2, R312.1, U301.20 (VCC), U302.7 (V_{DD2}), U302.20 (V_{DD}), U303.8 (VCC), U304.3 (VDD), U305.6 (V_{DD}), U306.1 (VDD); also elsewhere on the board
+5V: R303.1, R305.1, R316.1; also elsewhere on the board
/ADC_Vref: U304.6 (V_{ref}); also elsewhere on the board
/GAIN0: U302.9 (IO7); also elsewhere on the board
/GAIN1: U302.8 (IO8); also elsewhere on the board
/GAIN2: U302.6 (IO9); also elsewhere on the board
/GAIN3: U302.5 (IO10); also elsewhere on the board
/Imeas: R320.1; also elsewhere on the board
/Interface/CAL_MODE: R306.2, U301.14 (Y4), U302.19 (IO0)
/Interface/GAIN_0X: R317.2, U301.18 (Y0), U302.15 (IO4)
/Interface/GAIN_X0: R315.2, U301.17 (Y1), U302.16 (IO3)
/Interface/Imeas+: C307.1, R320.2, U302.2 (IO13), U305.3 (CH2+)
/Interface/Imeas-: C310.1, R321.2, U305.4 (CH2-)
/Interface/LOAD: R308.2, U301.15 (Y3), U302.18 (IO1)
/Interface/OFSmeas: C312.1, R324.2, U305.13 (CH4+)
/Interface/SAVE: R310.2, U301.16 (Y2), U302.17 (IO2)
/Interface/SCL: J302.1, J302.2, R309.1, U302.13 (SCL), U303.7 (SCL1), U304.5 (SCL), U305.8 (SCL)
/Interface/SDA: J302.3, J302.4, R311.1, U302.12 (SDA), U303.6 (SDA1), U304.4 (SDA), U305.7 (SDA)
/Interface/Temp: U302.3 (IO12), U305.11 (CH3+), U306.2 (VOUT)
/Interface/Vmeas+: C308.1, R322.2, U302.1 (IO14), U305.1 (CH1+)
/Interface/Vmeas-: C311.1, R323.2, U305.2 (CH1-)
/Interface/~EN: J301.8, Q303.1 (G), R301.1, R312.2, U301.1 (G1), U301.19 (G2)
/OFS: R321.1, R323.1, R324.1; also elsewhere on the board
/RLY_LOUT: Q304.3 (D); also elsewhere on the board
/Vmeas: R322.1; also elsewhere on the board
/rt: J303.2; also elsewhere on the board
GND: C305.2, C306.2, C307.2, C308.2, C309.2, C310.2, C311.2, C312.2, J304.2, R318.1, R319.1, U305.12 (CH3-), U305.14 (CH4-), U306.3 (GND); also elsewhere on the board
GNDD: C301.2, C302.2, C303.2, C304.2, J301.3, J301.7, J301.11, J301.14, J302.5, J302.6, Q301.2 (S), Q302.2 (S), Q304.2 (S), Q305.2 (S), R302.1, R304.1, R306.1, R307.1, R308.1, R310.1, R313.1, R314.1, R315.1, R317.1, R318.2, R319.2, U301.7 (A5), U301.8 (A6), U301.9 (A7), U301.10 (GND), U301.11 (Y7), U301.12 (Y6), U301.13 (Y5), U302.10 (GND), U303.4 (GND), U304.2 (VSS), U305.5 (V_{SS}), U305.9 (A0), U305.10 (A1)
unnamed: D301.2 (A), R303.2
unnamed: D301.1 (K), Q301.3 (D)
unnamed: D302.2 (A), R305.2
unnamed: D302.1 (K), Q302.3 (D)
unnamed: D303.2 (A), R316.2
unnamed: D303.1 (K), Q305.3 (D)
unnamed: J301.1, U301.2 (A0)
unnamed: J301.2, U301.3 (A1)
unnamed: J301.4, U301.4 (A2)
unnamed: J301.5, U301.5 (A3)
unnamed: J301.6, U301.6 (A4)
unnamed: J301.12, U303.2 (SCL0)
unnamed: J301.13, U303.3 (SDA0)
unnamed: J303.1, U304.1 (VOUT)
unnamed: J303.3, J304.1
unnamed: Q301.1 (G), R302.2, U302.14 (IO5)
unnamed: Q302.1 (G), R304.2, U302.11 (IO6)
unnamed: Q303.3 (D), R307.2, U303.5 (EN)
unnamed: Q304.1 (G), Q305.1 (G), R313.2, R314.2, TP301.1 (1_1), U302.4 (IO11)

Notes on the sheet:
No Fault (Blue)
Load (YellowGreen)
Address: 0x60
Output Fault (Red)
Address: 0x6C

Board: 4 copper layers, 100.0 x 100.0 mm, 183 parts (2 on the bottom side), 100 nets.
