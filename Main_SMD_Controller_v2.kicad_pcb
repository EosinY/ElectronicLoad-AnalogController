# Repository EosinY/ElectronicLoad-AnalogController (continued)

## KiCad design Main_SMD_Controller.kicad_pcb

Parts:
C1, C3, C6, C13: 1u; C_0603_1608Metric
C2: 0.47u; C_0603_1608Metric
C4, C7, C8, C9, C10, C11: 0.1u; C_0603_1608Metric
C5: 47u; CP_Elec_8x6.2
C12: 0.01u; C_0402_1005Metric
D1: GS1010FL; D_SOD-123
D2: D_Schottky; D_SOD-323
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: 2.1-5.5 +12VDC; MJ-179P(H)
J2: Switch_Control; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
J3: +5V; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J4: AnalogIO; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
J5: +12V; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J6: VsensJMP; PinHeader_1x03_P2.54mm_Vertical
J7: Drain; ScrewTerminal_01x01_PCB-20
J8: Gate; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J9: Source; ScrewTerminal_01x01_PCB-20
J10: Vin_-; ScrewTerminal_01x01_PCB-20
J11: Conn_01x02; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J12: Vsens; ScrewTerminal_01x01_PCB-20
J13: Vin+; ScrewTerminal_01x01_PCB-20
JP1: CLK_disable; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
P1: Eoshi-chan_Silk; Eoshi-chan_logo_15x15
P2: Eoshi-chan_Silk; Eoshi-chan-v2_10x10
P3: Serial_QR; Serial_QR_5x5
Q1: 2N7002K; SOT-23
R1: 20k; R_0603_1608Metric
R2, R3, R4, R5, R6, R7, R13, R14, R15, R16, R17, R18: 10k; R_0603_1608Metric
R8: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R9: 100; R_0603_1608Metric
R10: 150k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R11, R12: 20m; R_2512_6332Metric
RLY1: 943-1C-12DS; HSINDA-943_12A-1C_5p; MPN G5LE-14 DC5; Digi-Key_PN Z1011-ND
RV1: 10k; TSR065103R
RV2: 500; Potentiometer_Bourns_3296W_Vertical
RV3: 1k; Potentiometer_Bourns_3296W_Vertical
TH1: Thermistor; C_Disc_D3.0mm_W1.6mm_P2.50mm
TP1: CLK_in; TestPoint_Pad_2.0x2.0mm
U1: NJW4191M; DMP-8_5x5_P1.27mm
U2: NJM7805SDL1; TO-252-2
U3: TC74HC4066AP; DIP-14_W7.62mm_Socket
U4: AD8226ARZ; SOIC-8_3.9x4.9mm_P1.27mm
U5, U6: S-89713B-K8T2U; MSOP-8_3x3mm_P0.65mm; MPN LM358N; Digi-Key_PN LM358NFS-ND

Connections:
+12V: C2.1, D1.1 (K), D2.1 (K), J1.1, J5.1, RLY1.5 (COIL), U2.1 (VI)
/Imeas: J4.1, U3.8, U4.7
/LOAD_ENABLE-G: J2.4, Q1.1 (G), R6.2
/Load+: J6.3, J13.1, RLY1.3 (NO)
/MOS+: J7.1, RLY1.1 (COM)
/R+: J9.1, R11.1, R12.1, U4.4 (+)
/TH_1: J11.1, TH1.1
/TH_2: J11.2, TH1.2
/Vmeas: J4.2, R16.1, U6.1
/Vmeas_IN: J6.2, R10.2
/Vref: J4.3, U5.3
/Vsens: J6.1, J12.1
GND: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C13.2, J1.2, J2.5, J3.2, J4.5, J5.2, J8.2, JP1.2 (B), Q1.2 (S), R2.1, R3.2, R4.2, R5.2, R6.1, R15.2, R17.1, U1.3 (GND), U2.2 (GND), U3.7 (VSS), U3.12, U5.4 (GND), U6.4 (GND)
LOAD_ENABLE: D1.2 (A), Q1.3 (D), RLY1.2 (COIL)
unnamed: C12.1, RV1.1, RV1.2, U5.2
unnamed: C12.2, R9.1, U5.1
unnamed: J8.1, R9.2
unnamed: JP1.1 (A), TP1.1, U1.7 (CLK)
unnamed: R8.2, R10.1, U5.5
unnamed: R13.1, R14.1, U6.3
unnamed: R13.2, U5.6, U5.7
unnamed: R15.1, R16.2, U6.2
unnamed: R7.1, R17.2, U6.5
unnamed: RV1.3, U3.9
unnamed: RV2.1, U3.3
unnamed: RV3.1, U3.2
unnamed: C1.1, U1.2 (C+)
unnamed: C1.2, U1.4 (C-)
unnamed: R1.1, R2.2, U1.1 (FB)
unnamed: C6.1, R1.2, R18.1, U1.5 (Vout)
unnamed: U6.6, U6.7
R-: J10.1, R8.1, R11.2, R12.2, RLY1.4 (NC), U4.1 (-)
Rg_1: U3.1, U3.4, U4.2 (Rg)
Rg_2: RV2.2, RV2.3, RV3.2, RV3.3, U4.3 (Rg)
SHUNT_SELECT1: J2.2, R4.1, U3.5
SHUNT_SELECT2: J2.1, R3.1, U3.13
VCC: C3.1, C4.1, C5.1, C8.1, C9.1, C10.1, C11.1, D2.2 (A), J3.1, R7.2, U1.6 (ON/OFF), U1.8 (Vin), U2.3 (VO), U3.14 (VDD), U4.8 (Vs+), U5.8 (VCC), U6.8 (VCC)
VEE: C7.1, C13.1, R18.2, U4.5 (Vs-)
Vconst_ENABLE: J2.3, R5.1, U3.6
Vofs: J4.4, R14.2, U4.6 (Ref)

Notes on the sheet:
OPアンプのパスコン
0~48V
4066のパスコン
(Vofs+0)~(Vofs+2)V (Vofs=2)
(Vofs+0)~(Vofs+2.048)V (Vofs=2)

Board: 4 copper layers, 65.0 x 85.0 mm, 67 parts (1 on the bottom side), 40 nets.

## Commit log

2025-03-12 First
2025-03-12 Add .gitignore
2025-03-12 JLCPCB plugin test
2025-03-12 JLCPCB plugin test 2
2025-03-12 gitignorettest
2025-03-12 Add "Gerber" creation
2025-03-24 add BOM
2025-03-24 changed library
2025-04-04 Add negative power
2025-04-06 alpha 2
2025-04-23 fix pi controller
2025-04-23 4 layered
2025-04-24 fix voltage measure circuit
2025-04-24 1733
2025-04-27 bom and schematic pdf
2025-07-17 add v2 version
2025-07-17 simulation files
2025-09-10 unya
2025-11-13 デジタルIF
2025-11-17 電圧なににしよ
2025-11-19 Voltmeas simu
2025-11-19 おおまか
2025-11-19 おおまか２
2026-02-20 sims
2026-04-26 もうだめだ おしまいだ
2026-04-28 メインとPI制御の2分化
2026-05-02 いらんやろ
2026-05-20 aaaa
2026-05-21 kannsei
2026-05-21 Create GreenPAK_schem and BOM
2026-05-23 念のため
2026-05-23 部品配置
2026-05-23 ほぼ完成?
2026-05-24 ほぼ完成
2026-05-25 アノテーション変更前
2026-05-25 アノテーションリセット 余計なもんも消す
2026-05-26 図面とかBOMとか
2026-05-28 できたかも
2026-06-06 現状確定
2026-06-11 資料同期
